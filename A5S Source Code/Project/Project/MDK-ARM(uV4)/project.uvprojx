# Keil uVision project project.uvprojx, settings and files
target APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  AfterMake: fromelf.exe  --bin --output=BIN\APP.bin .\Flash\Obj\output.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,   STM32F10X_HD,   IS_APP
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc;..\..\TEXT;..\..\MALLOC;..\..\FATFS\exfuns;..\..\FATFS\src;..\..\PICTURE;..\..\APP;..\..\GUI;..\..\Step_motor;..\..\Dlion;..\..\GCODE;..\..\Thermistor
  library: MicroLIB
  memory RVCT4: ROM 0x800a000 size 0x76000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../../User/app/src/: main.c
  group BSP
    ../../User/bsp/src/: bsp_led.c bsp_timer.c bsp_key.c sys.c bsp_usart.c debug.c 24cxx.c myiic.c touch.c spi.c w25qxx.c lcd.c adc.c watchdog.c beep.c backup_sram.c pvd.c dma.c sdio_sdcard.c
    ../../User/bsp/: bsp.h bsp.c stm32f10x_it.c stm32f10x_assert.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group MALLOC
    ../../MALLOC/: malloc.c
  group TEXT
    ../../TEXT/: fontupd.c text.c
  group FATFS
    ../../FATFS/src/: diskio.c ff.c
    ../../FATFS/exfuns/: exfuns.c mycc936.c
  group GUI
    ../../GUI/: button.c gui.c progressbar.c
  group APP
    ../../APP/: common.c mainui.c print.c preheat.c app_gui.c welcome.c move.c powerOffPrint.c home.c extruder.c level.c fan.c set.c about.c uiFont.c uiPicture.c uiCalibrate.c uiLanguage.c speed.c
    ../../User/bsp/src/: fila.c
  group PICTURE
    ../../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group GCODE
    ../../GCODE/: gcodeplayer.c
  group MOTOR
    ../../Step_motor/: stepper.c
  group THERMISTOR
    ../../Thermistor/: temperature.c
  group DLION
    ../../Dlion/: ConfigurationStore.c Dlion.c motion_control.c planner.c
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.3.0
